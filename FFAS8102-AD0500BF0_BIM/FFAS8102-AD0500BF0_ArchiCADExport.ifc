Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-08-25T15:09:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Aug 25 15:09:50 2024 * Host: DCreative * Database: C:\Users\chatp\AppData\Local\Temp\3211e499-1c11-4351-9318-3c50579a1372\f36dca12-dea5-4452-b1e2-9fe8a5697b49\ifc * Database version: 5507 * Database creation date: Sun Aug 25 15:09:49 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Aug 25 15:09:49 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Aug 25 15:09:49 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcBuildingElementProxy: FFAS8102-AD0500BF0_REVIT:Sensor Foam Dispenser-AC/DC, FFAS8102-AD0500BF0_REVIT:Sensor Foam Dispenser-AC/DC:348497
In: Level 1
Type - Material: Brass, <Unnamed>, American Standard - Brass - Chrome
Type - Pset_BuildingElementProxyCommon - Reference: Sensor Foam Dispenser-AC/DC
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Sensor Foam Dispenser-AC/DC
Type - Pset_ProvisionForVoid - Width: 25 mm; Height: 171.5 mm; Depth: 136.3 mm
Material: American Standard - Brass - Chrome
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_348497
Description: Flow; FlowDirection: SOURCE
